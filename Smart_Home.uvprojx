# Keil uVision project Smart_Home.uvprojx, settings and files
target Smart_Home (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart_Home +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\user\inc;.\cmsis
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/: startup_stm32f10x_hd.s system_stm32f10x.c
  group user
    ./user/src/: main.c delay.c time.c uart.c LED.c DMA.c ESP8266.c RGB.c DHT11.c Motor.c USB.c OLED.c SPI.c font.c StepperMotor.c IR.c Http.c
